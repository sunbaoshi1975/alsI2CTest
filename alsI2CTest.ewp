# IAR project alsI2CTest.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L151CB-A ST STM32L151CB-A
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32L1XX_MD
  ICCARM.CCIncludePath2: USER\inc; stm32L151\STM32L1xx_StdPeriph_Driver\inc; stm32L151\CMSIS\Device\ST\STM32L1xx\Include; stm32L151\\CMSIS\Include; stm32L151\BSP; common; ALS_I2C_Driver_API\BH1750; ALS_I2C_Driver_API\sensirion
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: alsI2CTest.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; USE_STDPERIPH_DRIVER; STM32L1XX_MD
  ICCARM.CCOptLevel: 3
  group BSP
    stm32L151/BSP/: delay.c delay.h i2c.c i2c.h stm32l1xx_conf.h stm32l1xx_it.c stm32l1xx_it.h system_stm32l1xx.c timer.c timer.h usart2.c usart2.h wwdg.c wwdg.h
  group Common
    common/: common.c common.h
  group EWARM
    stm32L151/CMSIS/Device/ST/STM32L1xx/Source/Templates/iar/: startup_stm32l1xx_md.s
  group Sensor_Driver/ALS_I2C
    ALS_I2C_Driver_API/BH1750/: bh1750.c bh1750.h
  group Sensor_Driver/sensirion
    ALS_I2C_Driver_API/sensirion/: sensirion_arch_config.h sensirion_common.c sensirion_common.h sensirion_i2c.h sensirion_sw_i2c.c sensirion_sw_i2c_gpio.h sensirion_sw_i2c_implementation.c
  group StdPeriph_Driver/inc
    stm32L151/STM32L1xx_StdPeriph_Driver/inc/: misc.h stm32l1xx_adc.h stm32l1xx_aes.h stm32l1xx_comp.h stm32l1xx_crc.h stm32l1xx_dac.h stm32l1xx_dbgmcu.h stm32l1xx_dma.h stm32l1xx_exti.h stm32l1xx_flash.h stm32l1xx_fsmc.h stm32l1xx_gpio.h stm32l1xx_i2c.h stm32l1xx_iwdg.h stm32l1xx_lcd.h stm32l1xx_opamp.h stm32l1xx_pwr.h stm32l1xx_rcc.h stm32l1xx_rtc.h stm32l1xx_sdio.h stm32l1xx_spi.h stm32l1xx_syscfg.h stm32l1xx_tim.h stm32l1xx_usart.h stm32l1xx_wwdg.h
  group StdPeriph_Driver/src
    stm32L151/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_adc.c stm32l1xx_aes.c stm32l1xx_aes_util.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dac.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_fsmc.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_iwdg.c stm32l1xx_lcd.c stm32l1xx_opamp.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_sdio.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_wwdg.c
  group USER/inc
    USER/inc/: global.h main_functions.h sensorAls.h
  group USER/src
    USER/src/: main.c main_functions.c sensorAls.c
